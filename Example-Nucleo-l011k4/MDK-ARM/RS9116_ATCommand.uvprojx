# Keil uVision project RS9116_ATCommand.uvprojx, settings and files
target RS9116_ATCommand (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011K4Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: RS9116_ATCommand +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L011xx,USE_UART,RF_MODULE
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\Drivers\BSP\Inc;..\Drivers\BSP\Src;..\Drivers\Library\Inc;..\Drivers\Library\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Application/MDK-ARM
    ./: startup_stm32l011xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Driver/BSP
    ../Drivers/BSP/Src/: bsp_uart.c bsp_rf.c
    ../Drivers/Library/Src/: soft_timer.c
software components: CMSIS:CORE 4.3.0
